## kernel/security/asl/Kconfig
```kconfig
config ASL
	bool "ASL"
	help
	  This is ASL

config ASL_DISABLED
	bool "ASL_DISABLED"
	help
	  For disabling ASL
```
